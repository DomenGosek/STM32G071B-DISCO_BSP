# Keil uVision project Platform.uvprojx, settings and files
target STM32G071B-DISCO (6190000::V6.19::ARMCLANG)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: VIO_BUTTON_REMAP
  c include: .\Board_IO
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x20008800 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x8800
  scatter file: .\stm32g071.sct
  group App
    ./: Platform.c
  group Board IO
    ./Board_IO/: retarget_stdio.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32G071RBTx/STCubeGenerated/Src/: main.c stm32g0xx_it.c
    ./RTE/Device/STM32G071RBTx/STCubeGenerated/Inc/: stm32g0xx_it.h
  group STM32CubeMX
    ./RTE/Device/STM32G071RBTx/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS-Compiler:I/O:STDERR 1.0.0, CMSIS-Compiler:I/O:STDIN 1.0.0, CMSIS-Compiler:I/O:STDOUT 1.0.0, CMSIS-View:Event Recorder 1.5.2, CMSIS:CORE 5.7.0, CMSIS:OS Tick:SysTick 1.0.0, CMSIS:RTOS2:Keil RTX5 5.7.0, Board Support:Drivers:Basic I/O 1.2.1, CMSIS Driver:VIO:Board 2.0.0, Device:STM32Cube HAL:Common 1.4.5, Device:STM32Cube HAL:Cortex 1.4.5, Device:STM32Cube HAL:DMA 1.4.5, Device:STM32Cube HAL:EXTI 1.4.5, Device:STM32Cube HAL:GPIO 1.4.5, Device:STM32Cube HAL:PWR 1.4.5, Device:STM32Cube HAL:RCC 1.4.5, Device:STM32Cube HAL:UART 1.4.5, Device:Startup 1.6.0
